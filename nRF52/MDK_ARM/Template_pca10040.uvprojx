# Keil uVision project Template_pca10040.uvprojx, settings and files
target nrf52832_xxaa (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.32.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD MBEDTLS_CONFIG_FILE=<nrf_crypto_mbedtls_config.h> NRF52 NRF52832_XXAA NRF52_PAN_74 NRF_CRYPTO_MAX_INSTANCE_COUNT=1 __HEAP_SIZE=8192 __STACK_SIZE=8192 uECC_ENABLE_VLI_API=0 uECC_OPTIMIZATION_LEVEL=3 uECC_SQUARE_FUNC=0 uECC_SUPPORT_COMPRESSED_POINT=0 uECC_VLI_NATIVE_LITTLE_ENDIAN=1
  c misc: --reduce_paths
  c include: ..\Nordic_Drivers\config;..\Nordic_Drivers\components;..\Nordic_Drivers\components\boards;..\Nordic_Drivers\components\drivers_nrf\nrf_soc_nosd;..\Nordic_Drivers\components\libraries\atomic;..\Nordic_Drivers\components\libraries\atomic_fifo;..\Nordic_Drivers\components\libraries\balloc;..\Nordic_Drivers\components\libraries\bsp;..\Nordic_Drivers\components\libraries\button;..\Nordic_Drivers\components\libraries\cli;..\Nordic_Drivers\components\libraries\cli\uart;..\Nordic_Drivers\components\libraries\crc16;..\Nordic_Drivers\components\libraries\crc32;..\Nordic_Drivers\components\libraries\crypto;..\Nordic_Drivers\components\libraries\crypto\backend\cc310;..\Nordic_Drivers\components\libraries\crypto\backend\cc310_bl;..\Nordic_Drivers\components\libraries\crypto\backend\cifra;..\Nordic_Drivers\components\libraries\crypto\backend\mbedtls;..\Nordic_Drivers\components\libraries\crypto\backend\micro_ecc;..\Nordic_Drivers\components\libraries\crypto\backend\nrf_hw;..\Nordic_Drivers\components\libraries\crypto\backend\nrf_sw;..\Nordic_Drivers\components\libraries\crypto\backend\oberon;..\Nordic_Drivers\components\libraries\crypto\backend\optiga;..\Nordic_Drivers\components\libraries\csense;..\Nordic_Drivers\components\libraries\csense_drv;..\Nordic_Drivers\components\libraries\delay;..\Nordic_Drivers\components\libraries\ecc;..\Nordic_Drivers\components\libraries\experimental_section_vars;..\Nordic_Drivers\components\libraries\experimental_task_manager;..\Nordic_Drivers\components\libraries\fds;..\Nordic_Drivers\components\libraries\fifo;..\Nordic_Drivers\components\libraries\fstorage;..\Nordic_Drivers\components\libraries\gfx;..\Nordic_Drivers\components\libraries\gpiote;..\Nordic_Drivers\components\libraries\hardfault;..\Nordic_Drivers\components\libraries\hardfault\nrf52;..\Nordic_Drivers\components\libraries\hci;..\Nordic_Drivers\components\libraries\led_softblink;..\Nordic_Drivers\components\libraries\log;..\Nordic_Drivers\components\libraries\log\src;..\Nordic_Drivers\components\libraries\low_power_pwm;..\Nordic_Drivers\components\libraries\mem_manager;..\Nordic_Drivers\components\libraries\memobj;..\Nordic_Drivers\components\libraries\mpu;..\Nordic_Drivers\components\libraries\mutex;..\Nordic_Drivers\components\libraries\pwm;..\Nordic_Drivers\components\libraries\pwr_mgmt;..\Nordic_Drivers\components\libraries\queue;..\Nordic_Drivers\components\libraries\ringbuf;..\Nordic_Drivers\components\libraries\scheduler;..\Nordic_Drivers\components\libraries\sdcard;..\Nordic_Drivers\components\libraries\slip;..\Nordic_Drivers\components\libraries\sortlist;..\Nordic_Drivers\components\libraries\spi_mngr;..\Nordic_Drivers\components\libraries\stack_guard;..\Nordic_Drivers\components\libraries\stack_info;..\Nordic_Drivers\components\libraries\strerror;..\Nordic_Drivers\components\libraries\timer;..\Nordic_Drivers\components\libraries\twi_mngr;..\Nordic_Drivers\components\libraries\twi_sensor;..\Nordic_Drivers\components\libraries\uart;..\Nordic_Drivers\components\libraries\util;..\Nordic_Drivers\external\cifra_AES128-EAX;..\Nordic_Drivers\external\fnmatch;..\Nordic_Drivers\external\fprintf;..\Nordic_Drivers\external\mbedtls\include;..\Nordic_Drivers\external\micro-ecc\micro-ecc;..\Nordic_Drivers\external\nrf_cc310\include;..\Nordic_Drivers\external\nrf_oberon;..\Nordic_Drivers\external\nrf_oberon\include;..\Nordic_Drivers\external\nrf_tls\mbedtls\nrf_crypto\config;..\Nordic_Drivers\external\protothreads;..\Nordic_Drivers\external\protothreads\pt-1.4;..\Nordic_Drivers\external\thedotfactory_fonts;..\Nordic_Drivers\integration\nrfx;..\Nordic_Drivers\integration\nrfx\legacy;..\Nordic_Drivers\modules\nrfx;..\Nordic_Drivers\modules\nrfx\drivers\include;..\Nordic_Drivers\modules\nrfx\hal;..\Src
  asm define: APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52 NRF52832_XXAA NRF52_PAN_74 NRF_CRYPTO_MAX_INSTANCE_COUNT=1 __HEAP_SIZE=8192 __STACK_SIZE=8192 uECC_ENABLE_VLI_API=0 uECC_OPTIMIZATION_LEVEL=3 uECC_SQUARE_FUNC=0 uECC_SUPPORT_COMPRESSED_POINT=0 uECC_VLI_NATIVE_LITTLE_ENDIAN=1
  asm misc: --cpreproc_opts=-DAPP_TIMER_V2,-DAPP_TIMER_V2_RTC1_ENABLED,-DBOARD_PCA10040,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_74,-DNRF_CRYPTO_MAX_INSTANCE_COUNT=1,-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192,-DuECC_ENABLE_VLI_API=0,-DuECC_OPTIMIZATION_LEVEL=3,-DuECC_SQUARE_FUNC=0,-DuECC_SUPPORT_COMPRESSED_POINT=0,-DuECC_VLI_NATIVE_LITTLE_ENDIAN=1
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress 6330
  group Application
    ../Src/: main.c sdk_config.h
  group Board Definition
    ../Nordic_Drivers/components/boards/: boards.c
  group Board Support
    ../Nordic_Drivers/components/libraries/bsp/: bsp.c
  group nRF_Core
    ../Nordic_Drivers/components/libraries/mpu/: nrf_mpu_lib.c
    ../Nordic_Drivers/components/libraries/stack_guard/: nrf_stack_guard.c
  group nRF_Crypto
    ../Nordic_Drivers/components/libraries/crypto/: nrf_crypto_aead.c nrf_crypto_aes.c nrf_crypto_aes_shared.c nrf_crypto_ecc.c nrf_crypto_ecdh.c nrf_crypto_ecdsa.c nrf_crypto_eddsa.c nrf_crypto_error.c nrf_crypto_hash.c nrf_crypto_hkdf.c nrf_crypto_hmac.c nrf_crypto_init.c nrf_crypto_rng.c nrf_crypto_shared.c
  group nRF_Crypto backend Oberon
    ../Nordic_Drivers/components/libraries/crypto/backend/oberon/: oberon_backend_chacha_poly_aead.c oberon_backend_ecc.c oberon_backend_ecdh.c oberon_backend_ecdsa.c oberon_backend_eddsa.c oberon_backend_hash.c oberon_backend_hmac.c
  group nRF_Crypto backend cifra
    ../Nordic_Drivers/components/libraries/crypto/backend/cifra/: cifra_backend_aes_aead.c
  group nRF_Crypto backend mbed TLS
    ../Nordic_Drivers/components/libraries/crypto/backend/mbedtls/: mbedtls_backend_aes.c mbedtls_backend_aes_aead.c mbedtls_backend_ecc.c mbedtls_backend_ecdh.c mbedtls_backend_ecdsa.c mbedtls_backend_hash.c mbedtls_backend_hmac.c mbedtls_backend_init.c
  group nRF_Crypto backend nRF HW
    ../Nordic_Drivers/components/libraries/crypto/backend/nrf_hw/: nrf_hw_backend_init.c nrf_hw_backend_rng.c nrf_hw_backend_rng_mbedtls.c
  group nRF_Crypto backend uECC
    ../Nordic_Drivers/components/libraries/crypto/backend/micro_ecc/: micro_ecc_backend_ecc.c micro_ecc_backend_ecdh.c micro_ecc_backend_ecdsa.c
  group nRF_Drivers
    ../Nordic_Drivers/integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_power.c nrf_drv_ppi.c nrf_drv_rng.c nrf_drv_spi.c nrf_drv_spis.c nrf_drv_swi.c nrf_drv_twi.c nrf_drv_uart.c
    ../Nordic_Drivers/components/drivers_nrf/nrf_soc_nosd/: nrf_nvic.c nrf_soc.c
    ../Nordic_Drivers/modules/nrfx/hal/: nrf_nvmc.c
    ../Nordic_Drivers/modules/nrfx/soc/: nrfx_atomic.c
    ../Nordic_Drivers/modules/nrfx/drivers/src/: nrfx_clock.c nrfx_comp.c nrfx_gpiote.c nrfx_i2s.c nrfx_lpcomp.c nrfx_pdm.c nrfx_power.c nrfx_ppi.c nrfx_pwm.c nrfx_qdec.c nrfx_rng.c nrfx_rtc.c nrfx_saadc.c nrfx_spi.c nrfx_spim.c nrfx_spis.c nrfx_swi.c nrfx_systick.c nrfx_timer.c nrfx_twi.c nrfx_twim.c nrfx_twis.c nrfx_uart.c nrfx_uarte.c nrfx_wdt.c
    ../Nordic_Drivers/modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_Drivers_External
    ../Nordic_Drivers/components/libraries/twi_sensor/: nrf_twi_sensor.c
  group nRF_External
    ../Nordic_Drivers/external/thedotfactory_fonts/: orkney24pts.c orkney8pts.c
  group nRF_Libraries
    ../Nordic_Drivers/components/libraries/button/: app_button.c
    ../Nordic_Drivers/components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../Nordic_Drivers/components/libraries/fifo/: app_fifo.c
    ../Nordic_Drivers/components/libraries/gpiote/: app_gpiote.c
    ../Nordic_Drivers/components/libraries/pwm/: app_pwm.c
    ../Nordic_Drivers/components/libraries/scheduler/: app_scheduler.c
    ../Nordic_Drivers/components/libraries/sdcard/: app_sdcard.c
    ../Nordic_Drivers/components/libraries/timer/: app_timer2.c drv_rtc.c
    ../Nordic_Drivers/components/libraries/uart/: app_uart_fifo.c
    ../Nordic_Drivers/external/cifra_AES128-EAX/: blockwise.c cifra_cmac.c cifra_eax_aes.c eax.c gf128.c modes.c
    ../Nordic_Drivers/components/libraries/crc16/: crc16.c
    ../Nordic_Drivers/components/libraries/crc32/: crc32.c
    ../Nordic_Drivers/components/libraries/fds/: fds.c
    ../Nordic_Drivers/external/fnmatch/: fnmatch.c
    ../Nordic_Drivers/components/libraries/hardfault/nrf52/handler/: hardfault_handler_keil.c
    ../Nordic_Drivers/components/libraries/hardfault/: hardfault_implementation.c
    ../Nordic_Drivers/components/libraries/hci/: hci_mem_pool.c hci_slip.c hci_transport.c
    ../Nordic_Drivers/components/libraries/led_softblink/: led_softblink.c
    ../Nordic_Drivers/components/libraries/low_power_pwm/: low_power_pwm.c
    ../Nordic_Drivers/components/libraries/mem_manager/: mem_manager.c
    ../Nordic_Drivers/components/libraries/atomic_fifo/: nrf_atfifo.c
    ../Nordic_Drivers/components/libraries/atomic/: nrf_atomic.c
    ../Nordic_Drivers/components/libraries/balloc/: nrf_balloc.c
    ../Nordic_Drivers/components/libraries/cli/: nrf_cli.c
    ../Nordic_Drivers/components/libraries/cli/uart/: nrf_cli_uart.c
    ../Nordic_Drivers/components/libraries/csense/: nrf_csense.c
    ../Nordic_Drivers/components/libraries/csense_drv/: nrf_drv_csense.c
    ../Nordic_Drivers/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../Nordic_Drivers/components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_nvmc.c
    ../Nordic_Drivers/components/libraries/gfx/: nrf_gfx.c
    ../Nordic_Drivers/components/libraries/memobj/: nrf_memobj.c
    ../Nordic_Drivers/components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../Nordic_Drivers/components/libraries/queue/: nrf_queue.c
    ../Nordic_Drivers/components/libraries/ringbuf/: nrf_ringbuf.c
    ../Nordic_Drivers/components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../Nordic_Drivers/components/libraries/sortlist/: nrf_sortlist.c
    ../Nordic_Drivers/components/libraries/spi_mngr/: nrf_spi_mngr.c
    ../Nordic_Drivers/components/libraries/strerror/: nrf_strerror.c
    ../Nordic_Drivers/components/libraries/twi_mngr/: nrf_twi_mngr.c
    ../Nordic_Drivers/components/libraries/slip/: slip.c
    ../Nordic_Drivers/components/libraries/experimental_task_manager/: task_manager.c task_manager_core_keil.s
  group nRF_Log
    ../Nordic_Drivers/components/libraries/log/src/: nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Oberon_Crypto
    ../Nordic_Drivers/external/nrf_oberon/lib/cortex-m4/hard-float/short-wchar/: oberon_3.0.5.lib
  group nRF_TLS
    ../Nordic_Drivers/external/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group nRF_micro-ecc
    ../Nordic_Drivers/external/micro-ecc/nrf52hf_keil/armgcc/: micro_ecc_lib_nrf52.lib
  group nrf_cc310
    ../Nordic_Drivers/external/nrf_cc310/lib/cortex-m4/soft-float/short-wchar/: nrf_cc310_0.9.13.lib
software components: CMSIS:CORE 5.3.0, Device:Startup 8.32.1
